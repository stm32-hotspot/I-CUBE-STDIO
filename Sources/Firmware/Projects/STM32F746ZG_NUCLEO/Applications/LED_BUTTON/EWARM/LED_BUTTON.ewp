# IAR project LED_BUTTON.ewp, settings and files
configuration LED_BUTTON (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../STDIO/.; ../Components/.; ../Core/Inc; ../../../../../Drivers/STM32F7xx_HAL_Driver/Inc; ../../../../../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LED_BUTTON.hex
  ILINK.IlinkOutputFile: LED_BUTTON.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c custom.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/STDIO/Compiler/I O/STDOUT/USART
    ../../../../../Middleware/ST/STDIO/: stdout_usart.c
