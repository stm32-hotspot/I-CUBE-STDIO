# IAR project USBH_LCD.ewp, settings and files
configuration USBH_LCD (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Example/App; ../Example/.; ../Components/.; ../USB_HOST/App; ../USB_HOST/Target; ../Core/Inc; ../../../../../Drivers/STM32F7xx_HAL_Driver/Inc; ../../../../../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc; ../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/Groove
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_LCD.hex
  ILINK.IlinkOutputFile: USBH_LCD.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Application/User/Example/App
    ../Example/App/: app_I-CUBE-STDIO.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c usbh_platform.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/Groove/: LCD.h easy_rgb_lcd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Middlewares/STDIO/Compiler/I O/STDIN/USBH_HID_FS
    ../../../../../Middleware/ST/STDIO/: stdin_usbh_hid_fs.c
  group Middlewares/STDIO/Compiler/I O/STDOUT/LCD
    ../../../../../Middleware/ST/STDIO/: stdout_lcd.c
  group Middlewares/USB_Host_Library
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
